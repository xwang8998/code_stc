# Keil uVision project SMEC98SPfor8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W104 STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: SMEC98SPfor8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\SMEC98SP\Header;.\fpga_i2c;.\moni_I2C_A
  group Source Group 1
    ./: main.c
  group i2c
    ./moni_I2C_A/: MONI_I2C_A.C
